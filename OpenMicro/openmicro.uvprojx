# Keil uVision project openmicro.uvprojx, settings and files
target Target CG023 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F031K4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: openfly2 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F031
  c misc: --fpmode=fast
  c include: .\src ; ..\; ..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\Libraries\CMSIS\Include; ..\Libraries\STM32F0xx_StdPeriph_Driver\inc;  ..\Utilities\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group src
    ./src/: control.c main.c stickvector.c rx_cg023_protocol.c rx_bayang_protocol.c rx_bayang_protocol_ble.c rx_bayang_protocol_telemetry.c rx_h7_protocol.c rx_cx10blue_protocol.c rx_q282_protocol.c rx_syma_x5c_protocol.c gestures.c osd_ltm.c led.c rgb_led.c sixaxis.c motorcurve.c util.c imu.c flip_sequencer.c filter.cpp buzzer.c angle_pid.c pid.c defines.h hardware.h config.h debug.h flash.c rx_esky_et6i.c
  group drv
    ./src/: drv_adc.c drv_clk.c drv_fmc1.c drv_gpio.c drv_pwm.c drv_esc.c drv_serial.c drv_i2c.c drv_hw_i2c.c drv_softi2c.c drv_spi.c drv_time.c drv_xn297.c drv_rgb.c
  group Startup
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f031.s
  group Peripherals
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group SystemInit
    ../Utilities/: system_stm32f0xx.c
